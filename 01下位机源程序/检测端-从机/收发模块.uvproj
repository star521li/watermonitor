# Keil uVision project 收发模块.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC-STC90
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 收发模块 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c NRF24L01.c Delay.c
